#
# Recipe for UPS and PDU control
#
# Update with specific branch
# BRANCH="branch=master"

require upshttpd.inc
