#
# Recipe for upsdisplay
#
# BRANCH="branch='rev'"
#
require upsdisplay.inc
