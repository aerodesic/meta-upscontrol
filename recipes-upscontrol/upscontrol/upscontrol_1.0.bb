#
# Recipe for ups control
#
# BRANCH="branch='rev'"
#
require upscontrol.inc
