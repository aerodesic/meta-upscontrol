SUMMARY = "HDMI (default) frame buffer support"

require framebuffer.inc
