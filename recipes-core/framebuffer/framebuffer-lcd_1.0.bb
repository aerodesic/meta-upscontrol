SUMMARY = "PI Lcd version"

require framebuffer.inc
