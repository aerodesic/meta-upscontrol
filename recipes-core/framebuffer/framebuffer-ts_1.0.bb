SUMMARY = "Touch screen frame buffer"

require framebuffer.inc
